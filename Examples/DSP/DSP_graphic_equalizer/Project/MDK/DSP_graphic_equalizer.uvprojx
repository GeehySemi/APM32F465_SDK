# Keil uVision project DSP_graphic_equalizer.uvprojx, settings and files
target APM32F465 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F465VE Geehy
  pack: Geehy.APM32F465_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DSP_graphic_equalizer
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F465,APM32F465_MINI
  c include: ..\..\..\..\..\Libraries\APM32F465_StdPeriphDriver\inc;..\..\..\..\..\Libraries\Device\Geehy\APM32F465\Include;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Boards;..\..\Include;..\..\..\..\..\Libraries\CMSIS\DSP\PrivateInclude;..\..\..\..\..\Libraries\CMSIS\DSP\Include;..\..\..\..\..\Boards\Board_APM32F465_MINI\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../Source/: system_apm32f465.c
    ../../../../../Libraries/Device/Geehy/APM32F465/Source/arm/: startup_apm32f465.s
  group StdPeriphDriver
    ../../../../../Libraries/APM32F465_StdPeriphDriver/src/: apm32f465_adc.c apm32f465_can.c apm32f465_crc.c apm32f465_cryp.c apm32f465_cryp_aes.c apm32f465_cryp_des.c apm32f465_cryp_tdes.c apm32f465_dac.c apm32f465_dbgmcu.c apm32f465_dci.c apm32f465_dma.c apm32f465_dmc.c apm32f465_eint.c apm32f465_fmc.c apm32f465_gpio.c apm32f465_hash.c apm32f465_hash_md5.c apm32f465_hash_sha1.c apm32f465_i2c.c apm32f465_iwdt.c apm32f465_misc.c apm32f465_pmu.c apm32f465_rcm.c apm32f465_rng.c apm32f465_rtc.c apm32f465_sdio.c apm32f465_smc.c apm32f465_spi.c apm32f465_syscfg.c apm32f465_tmr.c apm32f465_usart.c apm32f465_wwdt.c
  group Boards
    ../../../../../Boards/: Board.c
  group Application
    ../../Source/: apm32f465_int.c main.c arm_graphic_equalizer_example_q31.c arm_graphic_equalizer_data.c math_helper.c
  group DSP_Lib
    ../../../../../Libraries/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../../../../Libraries/CMSIS/DSP/Source/BayesFunctions/: BayesFunctions.c
    ../../../../../Libraries/CMSIS/DSP/Source/CommonTables/: CommonTables.c
    ../../../../../Libraries/CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../../../../Libraries/CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ../../../../../Libraries/CMSIS/DSP/Source/DistanceFunctions/: DistanceFunctions.c
    ../../../../../Libraries/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../../../../../Libraries/CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c
    ../../../../../Libraries/CMSIS/DSP/Source/InterpolationFunctions/: InterpolationFunctions.c
    ../../../../../Libraries/CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../../../../../Libraries/CMSIS/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../../../../../Libraries/CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../../../../Libraries/CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c
    ../../../../../Libraries/CMSIS/DSP/Source/SVMFunctions/: SVMFunctions.c
    ../../../../../Libraries/CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c
  group Bsp
    ../../../../../Boards/Board_APM32F465_MINI/src/: bsp_key.c bsp_delay.c bsp_usart.c
