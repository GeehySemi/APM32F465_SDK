# Keil uVision project APM32F465_RT-thread.uvprojx, settings and files
target APM32F465_RT-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F465VE Geehy
  pack: Geehy.APM32F465_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APM32F465_RT-thread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F465,APM32F465_MINI
  c include: ..\..\..\..\..\Libraries\APM32F465_StdPeriphDriver\inc;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\Device\Geehy\APM32F465\Include;..\..\..\..\..\Boards;..\..\Include;../../../../../Middlewares/RealThread/rtthread-nano-master/rt-thread/include;../../../../../Middlewares/RealThread/rtthread-nano-master/rt-thread/components/finsh
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../../Source/: apm32f465_int.c main.c
  group CMSIS
    ../../Source/: system_apm32f465.c
    ../../../../../Libraries/Device/Geehy/APM32F465/Source/arm/: startup_apm32f465.s
  group StdPeriphDriver
    ../../../../../Libraries/APM32F465_StdPeriphDriver/src/: apm32f465_adc.c apm32f465_can.c apm32f465_crc.c apm32f465_cryp.c apm32f465_cryp_aes.c apm32f465_cryp_des.c apm32f465_cryp_tdes.c apm32f465_dac.c apm32f465_dbgmcu.c apm32f465_dci.c apm32f465_dma.c apm32f465_dmc.c apm32f465_eint.c apm32f465_fmc.c apm32f465_gpio.c apm32f465_hash.c apm32f465_hash_md5.c apm32f465_hash_sha1.c apm32f465_i2c.c apm32f465_iwdt.c apm32f465_misc.c apm32f465_pmu.c apm32f465_rcm.c apm32f465_rng.c apm32f465_rtc.c apm32f465_sdio.c apm32f465_smc.c apm32f465_spi.c apm32f465_syscfg.c apm32f465_tmr.c apm32f465_usart.c apm32f465_wwdt.c
  group Boards
    ../../../../../Boards/: Board.c
  group RT-Thread
    ../../../../../Middlewares/RealThread/rtthread-nano-master/rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../../../../../Middlewares/RealThread/rtthread-nano-master/rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../Source/: rtthread_board.c
  group Finsh
    ../../../../../Middlewares/RealThread/rtthread-nano-master/rt-thread/components/finsh/: cmd.c msh.c shell.c
    ../../Source/: finsh_port.c
