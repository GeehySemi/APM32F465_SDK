# IAR project FreeRTOS.ewp, settings and files
configuration APM32F465 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F465VE Geehy APM32F465VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APM32F465_MINI; APM32F465
  ICCARM.CCIncludePath2: ..\..\..\..\..\Boards; ..\..\..\..\..\Libraries\APM32F465_StdPeriphDriver\inc; ..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\Libraries\Device\Geehy\APM32F465\Include; ..\..\Include; ..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\portable\MemMang; ..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Include
  OBJCOPY.OOCOutputFile: FreeRTOS.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Geehy\apm32f465xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: apm32f465_int.c main.c
  group Boards
    ../../../../../Boards/: Board.c
  group CMSIS
    ../../../../../Libraries/Device/Geehy/APM32F465/Source/iar/: startup_apm32f465.s
    ../../Source/: system_apm32f465.c
  group FREE_RTOS
    ../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group StdPeriphDriver
    ../../../../../Libraries/APM32F465_StdPeriphDriver/src/: apm32f465_adc.c apm32f465_can.c apm32f465_crc.c apm32f465_cryp.c apm32f465_cryp_aes.c apm32f465_cryp_des.c apm32f465_cryp_tdes.c apm32f465_dac.c apm32f465_dbgmcu.c apm32f465_dci.c apm32f465_dma.c apm32f465_dmc.c apm32f465_eint.c apm32f465_fmc.c apm32f465_gpio.c apm32f465_hash.c apm32f465_hash_md5.c apm32f465_hash_sha1.c apm32f465_i2c.c apm32f465_iwdt.c apm32f465_misc.c apm32f465_pmu.c apm32f465_rcm.c apm32f465_rng.c apm32f465_rtc.c apm32f465_sdio.c apm32f465_smc.c apm32f465_spi.c apm32f465_syscfg.c apm32f465_tmr.c apm32f465_usart.c apm32f465_wwdt.c
